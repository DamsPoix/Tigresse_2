options:
  parameters:
    generate_options: qt_gui
    id: TG2_telem
    output_language: python
    title: Telem tigresse
  states: {}

blocks:
- name: bauds
  id: variable
  parameters:
    value: '100'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center frequency
    start: '869400000'
    step: '400'
    stop: '869600000'
    value: '869500000'
  states: {}
- name: doppler
  id: variable
  parameters:
    value: 1000*3
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '27000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (fsk_deviation_hz+doppler)*40
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: (fsk_deviation_hz+doppler)*2
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squeltch
    start: '-100'
    step: '1'
    stop: '0'
    value: '-55'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate2/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: int(samp_rate/samp_rate2)
    gain: '1'
    high_cutoff_freq: fsk_deviation_hz+doppler
    low_cutoff_freq: fsk_deviation_hz-doppler
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: doppler/4
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: sps*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: digital_clock_recovery_mm_xx_0_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: (samp_rate2/bauds)*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          carac = 0
          indexCarac = 0

          def __init__(self, thr=0.5):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.thr = thr
              self.carac = 0
              self.indexCarac = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              #print(input_items[0])
              for i in range(len(input_items[0])):
                  if(input_items[0][i] > self.thr):
                      #print("1",end="")
                      output_items[0][i] = 1
                      self.carac = self.carac + pow(2, self.indexCarac)
                      self.indexCarac = self.indexCarac + 1
                  elif(input_items[0][i] < -self.thr):
                      #print("0",end="")
                      output_items[0][i] = -1
                      self.indexCarac = self.indexCarac + 1
                  else:
                      output_items[0][i] = 0
                      self.carac = 0
                      self.indexCarac = 0

                  if(self.indexCarac >= 8):#end char
                      #print("")
                      if(int(self.carac) >= 48 and int(self.carac) <= 126):
                          print(chr(self.carac));
                      #print(int(self.carac))
                      self.carac = 0
                      self.indexCarac = 0

              #print(input_items[0])
              #output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    thr: '0.1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(samp_rate/(samp_rate2))
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate2/2, doppler/2)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '400'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate2
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '300'
    gain: '1'
    interp: '1'
    samp_rate: bauds*100
    type: interp_fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: (samp_rate2/100)/bauds
    type: float
  states: {state: disabled}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: '100'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"python output"'
    size: '200'
    srate: bauds
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: (fsk_deviation_hz+doppler)*2
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"lowPassOutput"'
    size: '2048'
    srate: bauds
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"resampled"'
    size: '200'
    srate: bauds
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"lowPassOutput1"'
    size: '2048'
    srate: samp_rate2
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate2/bauds)
    interp: bauds
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate2/bauds)
    interp: '100'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    corr0: '-10'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', low_pass_filter_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_1, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_char_to_float_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_clock_recovery_mm_xx_0_0, '0', epy_block_1, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [low_pass_filter_0, '0', digital_clock_recovery_mm_xx_0_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_1, '0']
- [low_pass_filter_1, '0', mmse_resampler_xx_0_0, '0']
- [low_pass_filter_1, '0', qtgui_time_sink_x_0_0_1, '0']
- [mmse_resampler_xx_0, '0', epy_block_1, '0']
- [mmse_resampler_xx_0_0, '0', epy_block_1, '0']
- [rational_resampler_xxx_0, '0', digital_binary_slicer_fb_1, '0']
- [rational_resampler_xxx_0, '0', epy_block_1, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_1, '0']
- [rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
