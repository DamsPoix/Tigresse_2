options:
  parameters:
    generate_options: qt_gui
    id: TG2_telem
    output_language: python
    title: Telem tigresse
  states: {}

blocks:
- name: bauds
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: bps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: center_freq
  id: variable_qtgui_range
  parameters:
    label: center frequency
    start: '869400000'
    step: '400'
    stop: '869600000'
    value: '869500000'
  states: {}
- name: doppler
  id: variable
  parameters:
    value: 1000*3
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '27000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (fsk_deviation_hz+doppler)*40
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: (fsk_deviation_hz+doppler)*2
  states: {}
- name: samp_rate3
  id: variable
  parameters:
    value: bauds*10
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    label: squeltch
    start: '-100'
    step: '1'
    stop: '0'
    value: '-55'
  states: {}
- name: analog_quadrature_demod_cf_1
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/(2*math.pi*fsk_deviation_hz)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: squelch
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: Haut-parleurs
    samp_rate: samp_rate3
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: fsk_deviation_hz+doppler
    low_cutoff_freq: fsk_deviation_hz-doppler
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: doppler/4
    win: window.WIN_HAMMING
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.3'
    init: '0'
    low: '-0.3'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\bolo.LAPTOP-0A1UK5DI\Documents\Tigresse_2\Telemetrie\TG2_telem_segment_sol - Copie\save.wav
    format: FORMAT_WAV
    samp_rate: samp_rate3
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""
          indexSampling = 0
          q1 = [1,1,1,1,1,1,1,1,1,1,1]
          lastBit = 1

          def pileSlide(self, val):
              for i in range(10):
                  self.q1[i] = self.q1[i+1]
              self.q1[10] = val

          def processPile(self):
              if(self.q1[0] == 0 and self.q1[9] == 1 and self.q1[10] == 1):#noice
                  carac = 0
                  for i in range(8):
                      carac = carac + pow(2,i)*self.q1[i+1]
                      self.q1[i+1] = 1
                  self.q1[0] = 1
                  self.q1[9] = 1
                  self.q1[10] = 1
                  if((int(carac) >= 32 and int(carac) <= 126) or int(carac) == 10):
                      print(chr(carac), end="")

          def __init__(self, baudrate=9600, sampling=100000):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.baudrate = baudrate
              self.sampling = sampling
              self.indexSampling = 0
              self.lastBit = 1
              for i in range(11):
                  self.q1[i] = 1

          def work(self, input_items, output_items):
              for i in range(len(input_items[0])):
                  bit = int(input_items[0][i])
                  if(self.lastBit == 1 and bit == 0):#falling
                      self.indexSampling = -1

                  if((self.indexSampling%int(self.sampling/self.baudrate)) == int((self.sampling/self.baudrate)/2)): #on est au milieu d un bit
                      self.pileSlide(bit)
                      self.processPile()

                  self.lastBit = bit
                  self.indexSampling = self.indexSampling + 1


              output_items[0][:] = input_items[0]
              return len(output_items[0])
    baudrate: bauds
    sampling: samp_rate3
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: int(samp_rate/(samp_rate2))
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate2/2, doppler/2)
    type: ccc
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '19200'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1920'
    win: window.WIN_BLACKMAN
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/samp_rate2
    type: complex
  states: {}
- name: mmse_resampler_xx_0_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: samp_rate/samp_rate3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"lowPassOutput"'
    size: '1024'
    srate: samp_rate3
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"quad output"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"lowPassOutput"'
    size: '1024'
    srate: samp_rate3
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate2
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    name: '"squetch"'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    corr0: '-10'
    freq0: center_freq
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_1, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_1, '0', qtgui_time_sink_x_0_0_1_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_1, '0']
- [analog_simple_squelch_cc_0, '0', mmse_resampler_xx_0, '0']
- [band_pass_filter_0, '0', analog_simple_squelch_cc_0, '0']
- [blocks_threshold_ff_0, '0', audio_sink_0, '0']
- [blocks_threshold_ff_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_threshold_ff_0, '0', epy_block_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_0_0_1, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0_1_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [low_pass_filter_0, '0', mmse_resampler_xx_0_0, '0']
- [mmse_resampler_xx_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [mmse_resampler_xx_0_0, '0', blocks_threshold_ff_0, '0']
- [rtlsdr_source_0, '0', band_pass_filter_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
